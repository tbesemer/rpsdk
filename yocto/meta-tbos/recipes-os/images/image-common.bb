LICENSE = "MIT"

PACKAGE_ARCH = "${MACHINE_ARCH}"

IMAGE_FSTYPES = "tar tar.gz jffs2 cpio.gz cpio.gz.u-boot"
